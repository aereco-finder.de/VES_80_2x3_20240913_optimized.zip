Properties of the parts of a building model (IFC2X3)

# File
Description: IFC2X3
File name: VES_80_2x3.IFC
Time: 2024-09-13T11:27:11
Written by: SwIFC
Made in: SolidWorks 2020 (Solibri IFC Optimizer)

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: 23869AL_SERRE CABLE ALDES^V2A(2)_VES_80 (2)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: 23869AL_SERRE CABLE ALDES; Part Number: 23869AL_SERRE CABLE ALDES; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: 86291AL^V2A(2)_VES_80 (2)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: 86291AL; Part Number: 86291AL; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: A2745_Joint pos_^SE3521_V2A(2)_VES_80
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: A2745_Joint pos_; Part Number: A2745_Joint pos_; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: A3364^A3501_V2A(2)_VES_80
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.001; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: A3364; Part Number: A3364; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: A3365^A3501_V2A(2)_VES_80
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.001; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: A3365; Part Number: A3365; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: A3366^A3501_V2A(2)_VES_80
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: A3366; Part Number: A3366; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: A3367^A3501_V2A(2)_VES_80
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: A3367; Part Number: A3367; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: A3368^A3501_V2A(2)_VES_80
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: A3368; Part Number: A3368; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: A3369^SE3521_V2A(2)_VES_80
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: A3369; Part Number: A3369; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: A3370^SE3519_V2A(2)_VES_80 (2)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: A3370; Part Number: A3370; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: A3371^MOTOTURBINE_EQUIPEE_SE3522_V2A(2)_VES_80
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: A3371; Part Number: A3371; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: A3372^MOTOTURBINE_EQUIPEE_SE3522_V2A(2)_VES_80
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: A3372; Part Number: A3372; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: A3373_Forme moulage^MOTOTURBINE_EQUIPEE_SE3522_V2A(2)_VES_80 (3)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: A3373_Forme moulage; Part Number: A3373_Forme moulage; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: A3374^SE3520_V2A(2)_VES_80 (2)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: A3374; Part Number: A3374; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: A3376^A3502_MOTOTURBINE_EQUIPEE_SE3522_V2A(2)_VES_80
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: A3376; Part Number: A3376; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: A3377^A3502_MOTOTURBINE_EQUIPEE_SE3522_V2A(2)_VES_80
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: A3377; Part Number: A3377; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: A3378^V2A(2)_VES_80 (4)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: A3378; Part Number: A3378; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: A3442_Version bouchon^SE3518_V2A(2)_VES_80 (2)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: A3442_Version bouchon; Part Number: A3442_Version bouchon; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: A3444^A3501_V2A(2)_VES_80 (2)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: A3444; Part Number: A3444; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: B3380_Forme d_coupe^SE3521_V2A(2)_VES_80
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: B3380_Forme d_coupe; Part Number: B3380_Forme d_coupe; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: B3381_Forme d_coupe^SE3518_V2A(2)_VES_80 (2)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: B3381_Forme d_coupe; Part Number: B3381_Forme d_coupe; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: B3381_Forme d_coupe^SE3519_V2A(2)_VES_80 (2)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: B3381_Forme d_coupe; Part Number: B3381_Forme d_coupe; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: B3382^SE3520_V2A(2)_VES_80 (2)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: B3382; Part Number: B3382; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: B3423^V2A(2)_VES_80
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: B3423; Part Number: B3423; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: B3483^MOTOTURBINE_EQUIPEE_SE3522_V2A(2)_VES_80
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: B3483; Part Number: B3483; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: K2675_BN13577^V2A(2)_VES_80 (3)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: K2675_BN13577; Part Number: K2675_BN13577; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: K3437_BN82428^V2A(2)_VES_80 (5)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: K3437_BN82428; Part Number: K3437_BN82428; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: K3497^V2A(2)_VES_80
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: K3497; Part Number: K3497; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: K5408_BN729^V2A(2)_VES_80 (4)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: K5408_BN729; Part Number: K5408_BN729; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: NONE (6)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf
Name | Nomenclature = Part Number
2 x NONE | V3334 - Turbine
4 x NONE | CE3782

# IfcBuildingElementProxy: V3334 - Axe_rotor^V3334_MOTOTURBINE_EQUIPEE_SE3522_V2A(2)_VES_80
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: V3334 - Axe_rotor; Part Number: V3334 - Axe_rotor; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: V3334 - Roulement^V3334_MOTOTURBINE_EQUIPEE_SE3522_V2A(2)_VES_80 (2)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: V3334 - Roulement; Part Number: V3334 - Roulement; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: V3334 - Stator^V3334_MOTOTURBINE_EQUIPEE_SE3522_V2A(2)_VES_80
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: V3334 - Stator; Part Number: V3334 - Stator; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcBuildingElementProxy: V3334 - Tole_rotor^V3334_MOTOTURBINE_EQUIPEE_SE3522_V2A(2)_VES_80
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Material: Material <nicht festgelegt>; Energieeffizienzklasse nach EU 1254 / 2014 Energieeffizienzklasse nach EU 1254 / 2014: A+; Nomenclature: V3334 - Tole_rotor; Part Number: V3334 - Tole_rotor; Source: NOT_KNOWN; Revision: ANY; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_am: 07.03.2024; Projektname: Step-Daten aus F; Erstellt_von: bf

# IfcElementAssembly: A3501^V2A(2)_VES_80
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.002; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_am: 07.03.2024; Projektnummer: P-00025; Erstellt_von: bf; Projektname: Step-Daten aus F

# IfcElementAssembly: A3502^MOTOTURBINE_EQUIPEE_SE3522_V2A(2)_VES_80
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_am: 07.03.2024; Projektnummer: P-00025; Erstellt_von: bf; Projektname: Step-Daten aus F

# IfcElementAssembly: MOTOTURBINE_EQUIPEE_SE3522^V2A(2)_VES_80
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_am: 07.03.2024; Projektnummer: P-00025; Erstellt_von: bf; Projektname: Step-Daten aus F

# IfcElementAssembly: SE3518^V2A(2)_VES_80 (2)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_am: 07.03.2024; Projektnummer: P-00025; Erstellt_von: bf; Projektname: Step-Daten aus F

# IfcElementAssembly: SE3519^V2A(2)_VES_80 (2)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_am: 07.03.2024; Projektnummer: P-00025; Erstellt_von: bf; Projektname: Step-Daten aus F

# IfcElementAssembly: SE3520^V2A(2)_VES_80 (2)
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_am: 07.03.2024; Projektnummer: P-00025; Erstellt_von: bf; Projektname: Step-Daten aus F

# IfcElementAssembly: SE3521^V2A(2)_VES_80
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_am: 07.03.2024; Projektnummer: P-00025; Erstellt_von: bf; Projektname: Step-Daten aus F

# IfcElementAssembly: V2A(2)^VES_80
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.002; Revision: ANY; Source: NOT_KNOWN; Part Number: V2A; Nomenclature: V2A; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_am: 07.03.2024; Projektnummer: P-00025; Erstellt_von: bf; Projektname: Step-Daten aus F

# IfcElementAssembly: V3334^MOTOTURBINE_EQUIPEE_SE3522_V2A(2)_VES_80
In: Default Storey
SolidWorks Custom Properties - Gewicht: 0.000; Bereinigungshinweis: Ein; Dateityp: Einzelteil; Erstellt_am: 07.03.2024; Projektnummer: P-00025; Erstellt_von: bf; Projektname: Step-Daten aus F

# IfcElementAssembly: VES_80_2x3
In: Default Storey
SolidWorks Custom Properties - Gewicht: 2.46; Source: NOT_KNOWN; Part Number: V2A; Nomenclature: V2A; Bereinigungshinweis: Aus; Dateityp: Einzelteil; Projektnummer: P-00025; Erstellt_von: bf; Projektname: Step-Daten aus F; Erstellt_am: 07.03.2024; Beschreibung2: V2A; Beschreibung: VES 80; Aenderungsgrund_Anzeige: Aus; Status: Konzeptphase
